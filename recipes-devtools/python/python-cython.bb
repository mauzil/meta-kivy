DESCRIPTION="Cython"
SECTION="devel/python"
LICENSE="Apache-2.0"
LIC_FILES_CHKSU="file://${COMMON_LICENSE_DIR}/Apache-2.0"
PYPI_PACKAGE = "Cython"
BBCLASSEXTED = "native nativesdk"


inherit pypi setuptools
